# Keil uVision project AT89C51_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: AT89C51_test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.a51 lab1.txt lab2.txt lab2_.txt
    $TC_ROOT$/../../Proteus/DATA/keilproject/: lab1_.txt lab3.txt lab3_.txt
